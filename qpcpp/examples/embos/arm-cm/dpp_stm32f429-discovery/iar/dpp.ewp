# IAR project dpp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\include; ..\..\..\..\..\source; ..\..\..\..\..\ports\embos; ..\..\..\..\..\3rd_party\embOS\Start\Inc; ..\..\..\..\..\3rd_party\stm32f4-discovery; ..\..\..\..\..\3rd_party\stm32f4-discovery\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: dpp.bin
  prebuild: cmd /c "if exist $OBJ_DIR$\qstamp.o del $OBJ_DIR$\qstamp.o"
  ILINK.IlinkOutputFile: dpp.out
  ILINK.IlinkIcfFile: dpp.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
configuration Spy (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: Q_SPY
  group (top)
    ./: ReadMe.txt
  group Application
    ../: bsp.cpp bsp.h dpp.h main.cpp philo.cpp table.cpp
    ../../../../../include/: qstamp.cpp
  group embOS
    ../../../../../3rd_party/embOS/Start/Lib/: os7m_tlv_r.a
  group QP
    ../../../../../source/: qep_hsm.cpp qep_msm.cpp qf_act.cpp qf_defer.cpp qf_dyn.cpp qf_mem.cpp qf_pkg.h qf_ps.cpp qf_qact.cpp qf_qeq.cpp qf_qmact.cpp qf_time.cpp
  group QP_port
    ../../../../../ports/embos/: qep_port.h qf_port.cpp qf_port.h qs_port.h
  group QS
    ../../../../../source/: qs.cpp qs_fp.cpp qs_pkg.h qs_rx.cpp
  group Setup
    Setup/: JLINKMEM_Process.c OS_Error.c RTOSInit_STM32F4x_CMSIS.c
  group stm32f4-discovery
    ../../../../../3rd_party/stm32f4-discovery/iar/: startup_stm32f4xx.s
    ../../../../../3rd_party/stm32f4-discovery/: stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h
    ../../../../../3rd_party/stm32f4-discovery/src/: stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c
