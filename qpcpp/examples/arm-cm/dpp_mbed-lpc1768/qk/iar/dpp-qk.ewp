# IAR project dpp-qk.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..; ..\..\..\..\..\include; ..\..\..\..\..\source; ..\..\..\..\..\ports\arm-cm\qk\iar; ..\..\..\..\..\3rd_party\CMSIS\Include; ..\..\..\..\..\3rd_party\mbed-lpc1768
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: dpp-qk.bin
  prebuild: cmd /c "if exist $OBJ_DIR$\qstamp.o del $OBJ_DIR$\qstamp.o"
  ILINK.IlinkOutputFile: dpp-qk.out
  ILINK.IlinkIcfFile: dpp-qk.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
configuration Spy (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: Q_SPY
  group Application
    ../: bsp.cpp
    ../../: bsp.h dpp.h main.cpp philo.cpp table.cpp
    ../../../../../include/: qstamp.cpp
  group mbed-lpc1768
    ../../../../../3rd_party/mbed-lpc1768/: LPC17xx.h system_LPC17xx.c system_LPC17xx.h
    ../../../../../3rd_party/mbed-lpc1768/iar/: startup_LPC17xx.s
  group QP
    ../../../../../source/: qep_hsm.cpp qep_msm.cpp qf_act.cpp qf_actq.cpp qf_defer.cpp qf_dyn.cpp qf_mem.cpp qf_pkg.h qf_ps.cpp qf_qact.cpp qf_qeq.cpp qf_qmact.cpp qf_time.cpp qk.cpp qk_mutex.cpp qk_pkg.h
  group QP_port
    ../../../../../ports/arm-cm/qk/iar/: qk_port.s
  group QS
    ../../../../../source/: qs.cpp qs_fp.cpp qs_pkg.h qs_rx.cpp
